# Keil uVision project STM32-LCD-TFT.uvprojx, settings and files
target STM3210B-EVAL (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32_RA8889 +hex
  c flags: OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_HD, USE_STM3210B_EVAL
  c include: .\user;.\FWlib\inc;.\fatfs;.\lcd;.\;.\RA8889_02_Function_Demo;.\RA8889_01_Kernel
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group User
    ./user/: fsmc_sram.c main.c stm32f10x_it.c sdcard.c RTC_Time.c delay.c SPI_Flash.c usart.c
    ./User/: W25N01GV.c
  group StdPeriph_Driver
    ./FWlib/SRC/: misc.c stm32f10x_exti.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_spi.c stm32f10x_dma.c stm32f10x_sdio.c stm32f10x_bkp.c stm32f10x_pwr.c stm32f10x_rtc.c stm32f10x_tim.c
  group RVMDK
    ./startup/: startup_stm32f10x_hd.s
  group CMSIS
    ./user/: core_cm3.c system_stm32f10x.c
  group fats
    ./fatfs/: ff.c diskio.c
  group RA8889_01_Kernel
    ./RA8889_01_Kernel/: RA8889.c RA8889_API.c RA8889_Application_Using_STM32.c RA8889_MCU_IF.c
  group RA8889_02_Function_Demo
    ./RA8889_02_Function_Demo/: API_Demo.c
target STM3210E-EVAL (ARM-ADS)
  device: STM32F103VB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM3210E-EVAL +hex
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_HD, USE_STM3210B_EVAL
  c include: ..\;..\..\..\Libraries\CMSIS\Core\CM3;..\..\..\Libraries\STM32F10x_StdPeriph_Driver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
software components: CMSIS:CORE 5.4.0
