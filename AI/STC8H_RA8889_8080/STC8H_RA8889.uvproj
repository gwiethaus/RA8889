# Keil uVision project STC8H_RA8889.uvproj, settings and files
target STC8H_RA8889 (MCS-51)
  device: STC8H8K64U Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x1FFF) IROM(0-0xFFF8) CLOCK(35000000)
  output: STC8H_RA8889 +hex
  c flags: Optimize=9 SizeSpeed=1
  c include: .\RA8889_01_Kernel
  link misc: REMOVEUNUSED
  group main
    ./: STARTUP.A51 main.c MCU_Dev_Board.c
  group RA8889_01_Kernel
    ./RA8889_01_Kernel/: delay.c RA8889_51.c RA8889_MCU_IF.c RA8889_API_51.c
  group doc
    ./doc/: readme.txt
